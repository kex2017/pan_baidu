# Keil uVision project START_KIT.uvproj, settings and files
target Start_Kit (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: START_KIT
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: __LCDDISPLAY_BTL001_LB_H
  c misc: --c99
  c include: .\Libraries;.\Include;.\Users
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Libraries/: startup_nano1xx.s
  group Libraries
    ./Libraries/: nano1xx_sys.c nano1xx_gpio.c nano1xx_isr.c nano1xx_spi.c nano1xx_i2c.c nano1xx_adc.c
  group Common
    ./Libraries/: nano1xx_retarget.c system_nano1xx.c
  group User
    ./Users/: main.c ht1621.c RC522.C public.c
